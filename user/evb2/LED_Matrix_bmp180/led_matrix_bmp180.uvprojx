# Keil uVision project led_matrix_bmp180.uvprojx, settings and files
target as32m0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: led_matrix_bmp180 +hex
  AfterMake: fromelf --bin -o led_matrix_bmp180.bin ./output/led_matrix_bmp180.axf
  AfterMake: fromelf -c -o led_matrix_bmp180.txt ./output/led_matrix_bmp180.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\as32m0;..\..\..\CMSIS;..\..\..\FWLib;..\..\..\printf_uart;.\Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group as32m0_startup
    ../../../as32m0/: startup_as32m0.s system_as32m0.c
  group FWLib
    ../../../FWLib/: as32m0_adc.c as32m0_des.c as32m0_dma.c as32m0_gpio.c as32m0_i2c.c as32m0_lvd.c as32m0_pinctrl.c as32m0_pwm.c as32m0_sleep.c as32m0_ssp.c as32m0_sysctrl.c as32m0_systick.c as32m0_timer.c as32m0_uart.c HardFaultHandler.c as32m0_misc.c as32m0_BMP180.c
  group user
    ./Src/: main.c LedControl.c LedControl.h max7219_config.h
  group printf
    ../../../printf_uart/: printf_config.c Retarget.c
